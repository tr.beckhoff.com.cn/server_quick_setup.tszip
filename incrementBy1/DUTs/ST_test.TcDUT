TYPE ST_test :
STRUCT
	a		:INT;
	b		:INT;
	c		:INT;
END_STRUCT
END_TYPE
